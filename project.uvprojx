# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;packages\gt9147-latest\inc;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;libraries\touchgfx_lib\TouchGFX;libraries\touchgfx_lib\TouchGFX\target;libraries\touchgfx_lib\TouchGFX\target\generated;libraries\touchgfx_lib\Middlewares\ST\touchgfx\framework\include;libraries\touchgfx_lib\TouchGFX\generated\fonts\include;libraries\touchgfx_lib\TouchGFX\generated\gui_generated\include;libraries\touchgfx_lib\TouchGFX\generated\images\include;libraries\touchgfx_lib\TouchGFX\generated\texts\include;libraries\touchgfx_lib\TouchGFX\gui\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: main.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_sdio.c drv_wlan.c drv_sdram.c drv_lcd.c drv_soft_i2c.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group gt9147
    packages/gt9147-latest/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Touch
    rt-thread/components/drivers/touch/: touch.c
  group TouchGFX_app
    libraries/touchgfx_lib/TouchGFX/target/generated/: OSWrappers_RTT.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp
    libraries/touchgfx_lib/TouchGFX/target/: STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
    libraries/touchgfx_lib/TouchGFX/App/: app_touchgfx.c sample_touchgfx.c
    libraries/touchgfx_lib/Middlewares/ST/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group TouchGFX_generated
    libraries/touchgfx_lib/TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp FontCache.cpp Font_NotoSans_Regular_12_4bpp_0.cpp GeneratedFont.cpp Kerning_NotoSans_Regular_12_4bpp.cpp Table_NotoSans_Regular_12_4bpp.cpp UnmappedDataFont.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/main_screen/: MainViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/: BitmapDatabase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX_gui
    libraries/touchgfx_lib/TouchGFX/gui/src/common/: FrontendApplication.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX_resource
    libraries/touchgfx_lib/TouchGFX/generated/images/src/__designer/: image_Blue_Backgrounds_Main_bg_480x272px.cpp image_Blue_Slider_Vertical_Small_Indicators_Slider3_Vertical_Round_nob.cpp image_Blue_Slider_Vertical_Small_Slider3_Vertical_Round_back.cpp image_Blue_Slider_Vertical_Small_Slider3_Vertical_Round_fill.cpp
